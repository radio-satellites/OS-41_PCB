# Repository radio-satellites/OS-41_PCB

## KiCad design OS-41.kicad_pcb

Parts:
AE2: 1575AT43A0040; ANT_1575AT_JOT; LCSC C239243
C1: 12pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 8.2pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3: 9.1pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C7, C9, C11, C12, C14, C27, C28, C44, C45, C46, C47, C48: 100nF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 4.7uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6: 120pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C13: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10: 22uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C29: 1.5pF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder; LCSC C1525
C32, C33: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C36, C37: 14pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C43: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D3: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Conn_02x03_Counter_Clockwise; PinHeader_2x03_P2.54mm_Vertical
J2, J3: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_Coaxial; SMA_Amphenol_901-144_Vertical
J5: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
L1: 270nH; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
L2: 11nH; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
L3, L5: 24nH; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
L4: 39nH; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
L6: 4.7uH; IND-SMD_L3.3-W3.0
L8, L9: 3.9 nH; L_0402_1005Metric_Pad0.77x0.64mm_HandSolder; LCSC C307609
R1: 50R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R5, R6, R9, R13, R14, R18: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3: 976k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 562k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11, R12: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW4: SW_Push; SMD_SW_NEW_REDONE
U1: BME280; Bosch_LGA-8_2.5x2.5mm_P0.65mm_ClockwisePinNumbering
U2: SI4432-B1-FMR; QFN50P400X400X90-21N; Manufacturer_Part_Number SI4432-B1-FMR; Mouser Part Number 634-SI4432-B1-FMR
U3: MCP1640x-xCHY; SOT-23-6
U4: ATGM336H-5N31; GPSM-SMD_ATGM336H-TR; LCSC Part C90770
U7: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm
Y1: 32.768KHz 12.5pF; Crystal_SMD_3215-2Pin_3.2x1.5mm
Y2: 8MHz 12pF; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y3: 30MHz 10pF; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
BATT: C5.2, J3.1, L6.1, U3.3 (EN), U3.6 (V_{IN}), U7.11 (ADC1_IN1)
GND: C2.1, C3.1, C4.2, C5.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C27.2, C28.2, C32.1, C33.1, C36.1, C37.1, C43.2, C44.1, C45.1, C46.1, C47.1, C48.1, D1.1 (K), D2.1 (K), D3.1 (K), J1.5, J2.2, J3.2, J4.2 (Ext), J5.1, L8.1, L9.1, R1.1, R4.2, R6.2, SW4.1, U1.1 (GND), U1.7 (GND), U2.21 (EP), U3.2 (GND), U4.1 (GND), U4.10 (GND), U4.12 (GND), U7.8 (VSSA), U7.23 (VSS), U7.35 (VSS), U7.47 (VSS), Y2.2, Y2.4, Y3.2, Y3.4
GPSPAUSE: R2.2, U4.5 (ON/OFF), U7.45 (PB8)
LED_ERR: R11.2, U7.39 (PB3)
LED_OK: R10.2, U7.40 (PB4)
NIRQ: U2.17 (NIRQ), U7.29 (PA8)
NSEL: U2.16 (NSEL), U7.14 (SPI1_NSS)
unnamed: AE2.1 (A), C29.2, L8.2
unnamed: C1.1, L2.1, R1.2
unnamed: C1.2, C6.2, L2.2, L3.1
unnamed: C2.2, L3.2, L4.1
unnamed: C3.2, L4.2, L5.1
unnamed: D1.2 (A), R10.1
unnamed: D2.2 (A), R11.1
unnamed: D3.2 (A), R12.1
unnamed: J4.1 (In), L5.2
unnamed: R18.2, U1.2 (CSB)
unnamed: R9.1, U1.5 (SDO)
unnamed: C6.1, L1.2, U2.2 (TX)
unnamed: C8.1, U2.10 (VR_DIG)
unnamed: U2.19 (XIN), Y3.1
unnamed: U2.18 (XOUT), Y3.3
unnamed: L6.2, U3.1 (SW)
unnamed: R3.2, R4.1, U3.4 (V_{FB})
unnamed: C29.1, L9.2, U4.11 (RF_IN)
unnamed: R6.1, U7.44 (BOOT0)
PA15: J1.4, U7.38 (PA15)
PB12: J5.3, U7.25 (PB12)
PB13: J5.2, U7.26 (PB13)
RCC_OSC32_IN: C32.2, U7.3 (RCC_OSC32_IN), Y1.1
RCC_OSC32_OUT: C33.2, U7.4 (RCC_OSC32_OUT), Y1.2
RST: C43.1, J1.3, R5.2, SW4.2, U7.7 (NRST)
RXD: U4.3 (RXD), U7.12 (USART2_TX)
SCL: R14.1, U1.4 (SCK), U7.42 (I2C1_SCL)
SCLK: U2.15 (SCLK), U7.15 (SPI1_SCK)
SDA: R13.2, U1.3 (SDI), U7.43 (I2C1_SDA)
SDI: U2.14 (SDI), U7.17 (SPI1_MOSI)
SDN: U2.20 (SDN), U7.30 (PA9)
SDO: U2.13 (SDO), U7.16 (SPI1_MISO)
SYS_JTCK-SWCLK: J1.2, U7.37 (SYS_JTCK-SWCLK)
SYS_JTMS-SWDIO: J1.1, U7.34 (SYS_JTMS-SWDIO)
TXD: U4.2 (TXD), U7.13 (USART2_RX)
VCC: C4.1, C7.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.2, C27.1, C28.1, C44.2, C45.2, C46.2, C47.2, C48.2, J1.6, J2.1, L1.1, R2.1, R3.1, R5.1, R9.2, R12.2, R13.1, R14.2, R18.1, U1.6 (VDDIO), U1.8 (VDD), U2.1 (VDD_RF), U2.12 (VDD_DIG), U3.5 (V_{OUT}), U4.6 (VBAT), U4.8 (VCC), U4.9 (NRESET), U7.1 (VBAT), U7.9 (VDDA), U7.24 (VDD), U7.36 (VDD), U7.48 (VDD)
X_IN: C36.2, U7.5 (RCC_OSC_IN), Y2.3
X_OUT: C37.2, U7.6 (RCC_OSC_OUT), Y2.1

Notes on the sheet:
This is a C285642
C51927445
Power
LEDs to indicate status
Oh boy do I love the 'ol AVR ISP headers
This filters the power supply!
GPS, for telling where we are
Sensors to read data
LEDs!
I am unsure why this doesn't need capacitors. It works ¯\_(ツ)_/¯
Radio
The MCP1640 boosts 3v/1.5v to 3.3v for operation from batteries
STM32F103/MCU
The Si4432 sends Horus Binary packets down to the ground
Wired up in I2C Mode
GPS
Note: I initially really messed the matching up. The Si4432 PA is a switching PA, so it needs some unusual matching networks. Check out AN435
Sensors

Board: 4 copper layers, 32.5 x 61.0 mm, 66 parts (0 on the bottom side), 45 nets.

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
AE2,ANT_1575AT_JOT,1,1575AT43A0040,C239243
C1,0603,1,12pF,
C10,0603,1,22uF,
"C11, C12, C14, C27, C28, C4, C44, C45, C46, C47, C48, C7, C9",0603,13,100nF,
"C13, C8",0603,2,1uF,
C2,0603,1,8.2pF,
C29,0402,1,1.5pF,C1525
C3,0603,1,9.1pF,
"C32, C33",0603,2,15pF,
"C36, C37",0603,2,14pF,
C43,0603,1,10uF,
C5,0603,1,4.7uF,
C6,0603,1,120pF,
"D1, D2, D3",0805,3,LED,
J1,PinHeader_2x03_P2.54mm_Vertical,1,Conn_02x03_Counter_Clockwise,
"J2, J3",PinHeader_1x02_P2.54mm_Vertical,2,Conn_01x02_Pin,
J4,SMA_Amphenol_901-144_Vertical,1,Conn_Coaxial,
J5,PinHeader_1x03_P2.54mm_Vertical,1,Conn_01x03,
L1,0603,1,270nH,
L2,0603,1,11nH,
"L3, L5",0603,2,24nH,
L4,0603,1,39nH,
L6,IND-SMD_L3.3-W3.0,1,4.7uH,
"L8, L9",0402,2,3.9 nH,C307609
R1,0603,1,50R,
"R10, R11, R12",0603,3,1k,
"R13, R14, R18, R2, R5, R6, R9",0603,7,10k,
R3,0603,1,976k,
R4,0603,1,562k,
SW4,SMD_SW_NEW_REDONE,1,SW_Push,
U1,Bosch_LGA-8_2.5x2.5mm_P0.65mm_ClockwisePinNumbering,1,BME280,
U2,QFN50P400X400X90-21N,1,SI4432-B1-FMR,
U3,SOT-23-6,1,MCP1640x-xCHY,
U4,GPSM-SMD_ATGM336H-TR,1,ATGM336H-5N31,C90770
U7,LQFP-48_7x7mm_P0.5mm,1,STM32F103C8Tx,
Y1,Crystal_SMD_3215-2Pin_3.2x1.5mm,1,32.768KHz 12.5pF,
Y2,Crystal_SMD_3225-4Pin_3.2x2.5mm,1,8MHz 12pF,
Y3,Crystal_SMD_3225-4Pin_3.2x2.5mm,1,30MHz 10pF,

## Commit log

2024-11-18 Add PCB
2024-11-22 Add things
2024-11-22 Add temp. sensor lables
2024-11-25 Final PCB
2024-12-07 RevB
2025-01-16 Final things
2025-02-01 Major board revamp!
2025-02-02 Small changes
2025-02-02 rename to boot
2025-02-02 move PWR
2025-02-02 Clean up USB routing
2025-02-02 usb oops
2025-02-03 Adjust some silkscreen markings
2025-02-03 more
2025-02-03 oops
2025-02-03 Reverse GPIO markings
2025-02-03 fixed decouple capacitor
2025-02-06 Move L6
2025-02-06 add polarity
2025-02-11 Fix some important things
2025-02-11 Rotate a capacitor
2025-02-11 Fix some silkscreen issues
2025-02-13 Add silkscreen graphics
2025-02-13 Refill zones
2025-02-14 Place USB resistors closer to chip
2025-02-14 Fixed up some routing
2025-02-14 Add GPS ANT text
2025-02-15 Fix things
2025-02-16 Add comments to schematic
2025-02-17 Fix minor footprint things
2025-02-21 Change designator to X2
2025-02-21 Move some capacitors
2025-02-21 Moved silkscreen text (oops)
2025-02-22 BMP390 oops (add pullup resistor for address selection)
2025-02-22 Move some silkscreen around
2025-02-22 Move R6 and R7
2025-02-24 Change I2C pullup values
2025-02-24 Rebuild zones
2025-02-24 Fix some final DRC things
2025-02-24 Tried to reroute VBUS
2025-02-24 Move PWR text
2025-02-25 Resistor markings change
2025-02-25 Move a few decoupling capacitors away for the radio IC
2025-02-26 Final
2025-02-26 Final board
2025-03-26 Board
2025-03-31 Final RP2040 version (byeeeeeeee RP2040)
2025-04-05 Remove PCB board, start work on STM32F411
2025-04-11 Progress
2025-04-17 Preliminary board
2025-05-10 Add 3d models
2025-05-10 Fix a few more things
2025-06-10 Change GPS antenna + routing fixes
2025-07-27 Add GPS text
2025-11-12 Remaking the PCB... again...
2025-11-13 Continue layout
2025-11-14 More layout, no routing yet...
2025-11-15 Finished V1 layout!
2025-11-15 Layout initial done
2025-11-16 Start routing!
2025-11-16 Continue routing
2025-11-16 Routed first version!
2025-11-16 More routing!
2025-11-16 RF trace reroute
2025-11-16 Link more 3d models
2025-11-18 More routing...
2025-11-18 Add GPIO breakouts
2025-11-19 oops...push via
2025-11-22 Fix up DRC
2025-11-22 Add final DRC things
2025-11-30 FINALLY found the button footprint...
2025-12-01 add notice
